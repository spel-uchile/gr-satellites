<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>suchai</value></param>
<param><key>author</key><value>Carlos Gonzalez</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>SUCHAI 1 Decoder based on Daniel Estevez's GOMX-1 decoder</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>SUCHAI 1 Decoder</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff_freq</value></param>
<param><key>value</key><value>1400</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cutoff_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>2600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>demod_freq</value></param>
<param><key>value</key><value>-1800</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>demod_freq</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>-3600</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>packlen</value></param>
<param><key>value</key><value>(255+3)*8</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>48000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_symbol</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samples_symbol</value></param>
<param><key>value</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sync</value></param>
<param><key>value</key><value>"11000011101010100110011001010101"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>demod_freq</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_conjugate_cc</key>
<param><key>id</key><value>blocks_conjugate_cc_0</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tagged_stream_multiply_length</key>
<param><key>id</key><value>blocks_tagged_stream_multiply_length_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>c</key><value>1/8.0</value></param>
<param><key>lengthtagname</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_wavfile_source</key>
<param><key>id</key><value>blocks_wavfile_source_0</value></param>
<param><key>file</key><value>/home/carlos/Descargas/suchai_test.wav</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>digital_correlate_access_code_tag_xx</key>
<param><key>id</key><value>digital_correlate_access_code_tag_bb_0_0_0</value></param>
<param><key>access_code</key><value>sync</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tagname</key><value>syncword</value></param>
<param><key>threshold</key><value>threshold</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>digital_gmsk_demod_0</value></param>
<param><key>freq_error</key><value>0.0</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>samples_per_symbol</key><value>samples_symbol</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter_0</value></param>
<param><key>cutoff_freq</key><value>cutoff_freq</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>width</key><value>1000</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>4k8 Variables</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>2k4 Variables</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1</value></param>
<param><key>note</key><value>Input section</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0</value></param>
<param><key>note</key><value>Demodulation section</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0_0</value></param>
<param><key>note</key><value>Framing section</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_1_0_0_0</value></param>
<param><key>note</key><value>Decode section</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>packlen</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>stemplot</key><value>True</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>packlen+1000</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>stemplot</key><value>True</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>syncword</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"green"</value></param>
<param><key>label1</key><value></value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>size</key><value>packlen+1000</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>stemplot</key><value>True</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_TAG</value></param>
<param><key>tr_tag</key><value>packet_len</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.00001</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>2048</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>int_max</key><value>0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.00001</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>satellites_fixedlen_tagger</key>
<param><key>id</key><value>satellites_fixedlen_tagger_0_0_0</value></param>
<param><key>packetlen_tag</key><value>packet_len</value></param>
<param><key>packet_len</key><value>packlen</value></param>
<param><key>stream_type</key><value>byte</value></param>
<param><key>syncword_tag</key><value>syncword</value></param>
</block>
<block>
<key>satellites_print_csp_message</key>
<param><key>id</key><value>satellites_print_csp_message_0</value></param>
</block>
<block>
<key>satellites_print_timestamp</key>
<param><key>id</key><value>satellites_print_timestamp_0</value></param>
<param><key>fmt</key><value>%Y-%m-%d %H:%M:%S</value></param>
</block>
<block>
<key>satellites_suchai_telemetry</key>
<param><key>id</key><value>satellites_suchai_telemetry_0</value></param>
</block>
<block>
<key>satellites_u482c_decode</key>
<param><key>id</key><value>satellites_u482c_decode_0</value></param>
<param><key>rs</key><value>1</value></param>
<param><key>scrambler</key><value>1</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>viterbi</key><value>0</value></param>
</block>
<block>
<key>zeromq_pub_msg_sink</key>
<param><key>id</key><value>zeromq_pub_msg_sink_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5556</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_sub_msg_source</key>
<param><key>id</key><value>zeromq_sub_msg_source_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:5556</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_conjugate_cc_0</source_block_id><sink_block_id>low_pass_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>blocks_conjugate_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_multiply_length_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0_0</source_block_id><sink_block_id>satellites_u482c_decode_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blocks_tagged_stream_multiply_length_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_wavfile_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_correlate_access_code_tag_bb_0_0_0</source_block_id><sink_block_id>satellites_fixedlen_tagger_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>blocks_char_to_float_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_gmsk_demod_0</source_block_id><sink_block_id>digital_correlate_access_code_tag_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>digital_gmsk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_fixedlen_tagger_0_0_0</source_block_id><sink_block_id>blocks_char_to_float_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_fixedlen_tagger_0_0_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>satellites_print_timestamp_0</source_block_id><sink_block_id>satellites_print_csp_message_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_print_timestamp_0</source_block_id><sink_block_id>satellites_suchai_telemetry_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_suchai_telemetry_0</source_block_id><sink_block_id>zeromq_pub_msg_sink_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>satellites_u482c_decode_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>satellites_u482c_decode_0</source_block_id><sink_block_id>satellites_print_timestamp_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>zeromq_sub_msg_source_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
</flow_graph>
